RAM1_ADR	EQU		0x20000000
RAM2_ADR	EQU		0x20000100
	
		AREA myCode, CODE, READONLY
		ENTRY
		EXPORT __main
			
__main
		BL		FILLRAM1
		BL		COPY
		
STOP	B	STOP

FILLRAM1
		LDR R1,=RAM1_ADR
		MOV R0,#0x10
		LDR R2,=0xDEADBEEF
		
L1		STR	R2,[R1]
		ADD	R1,R1,#4
		ADD R2,R2,#1
		SUBS R0,R0,#1
		BNE L1
		BX	LR
		
COPY
		LDR R1,=RAM1_ADR
		LDR	R2,=RAM2_ADR
		MOV R0,#10
		
L2		LDR	R3,[R1]
		STR R3,[R2]
		ADD R1,R1,#4
		ADD R2,R2,#4
		SUBS R0,R0,#1
		BNE L2
		BX 	LR
		
		
		END
		
		
		 
		
			
		